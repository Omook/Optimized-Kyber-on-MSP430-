# IAR project test_dilithium2_yb.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F6779A MSP430F6779A
  General.GStackSize2: 30000
  General.GHeapSize2: 1000
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f6779a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: api.h asm_basemul_fnt_mont.s43 asm_fnt_mont.s43 asm_invfnt_mont.s43 asm_InvNTT.s43 asm_NTT.s43 asm_reduce.s43 asm_sha3.s43 dil2_basemul.s43 fips202.c fips202.h fnt_main.c fnt_main.h main.c ntt.c ntt.h packing.c packing.h params.h poly.c poly.h polyvec.c polyvec.h randombytes.c randombytes.h reduce.c reduce.h rounding.c rounding.h sign.c sign.h symmetric-shake.c symmetric.h
