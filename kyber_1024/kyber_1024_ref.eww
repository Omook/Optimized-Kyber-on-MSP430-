<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\kyber_1024_ref.ewp</path>
    </project>
    <batchBuild />
</workspace>
