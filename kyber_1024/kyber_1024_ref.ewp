# IAR project kyber_1024_ref.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlmfn.h
  General.OGChipSelectMenu: MSP430F67791 MSP430F67791
  General.GStackSize2: 29000
  General.GHeapSize2: 2000
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f67791.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: api.h asm_basemul_kyber.s43 asm_INTT_Kyber.s43 asm_NTT_Kyber.s43 asm_reduce_kyber.s43 asm_sha3.s43 cbd.c cbd.h fips202.c fips202.h indcpa.c indcpa.h kem.c kem.h main.c ntt.c ntt.h params.h poly.c poly.h polyvec.c polyvec.h reduce.c reduce.h symmetric-shake.c symmetric.h verify.c verify.h
